# Keil uVision project lcd.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lcd
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include;.\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: LCD.c main.c startup_stm32l476xx.s SysTimer.c SysTimer.h
    ../../../../../../STM32L476G_ADC/STM32L476G_ADC/: ADC.c SysClock.c
software components: CMSIS:CORE 5.3.0
